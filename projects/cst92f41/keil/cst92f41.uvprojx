# Keil uVision project cst92f41.uvprojx, settings and files
target cst92f41 (6230000::V6.23::ARMCLANG)
  device: CST92F41KxVxxx Chipsea
  pack: Chipsea.CST92Fxx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x14000) IROM(0x00400000,0x00100000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ble_app_simple_cmsisos2_freertos +hex
  AfterMake: fromelf.exe --bin --output "$L..\bin\@L.bin" "#L"
  AfterMake: fromelf.exe --i32combined  --output "$L..\bin\@L.hex" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_CST92F41=1,CONFIG_LIB_PRESET_BLE_1PERIPHERAL,CONFIG_AUTOCONF_PRESET,_start=main
  c include: ../../../rtos/FreeRTOS/Source/Portable/chipsea/GCC/port.c;../../../bsp/include;../../../bsp/CST92F4X_EVB;../../../common;../../../components/shell;../../../components/unity;../../../components/ble/include;../../../components/ble/controller/include;../../../components/ble/host/include;../../../components/ble/mesh/include;../../../components/ble/controller;../../../components/ble/controller/include;../../../components/ble/controller/main;../../../components/ble/controller/cc;../../../components/ble/controller/llp;../../../components/ble/controller/dbg;../../../components/ble/controller/ecc_p256;../../../components/ble/controller/co;../../../components/ble/controller/rf;../../../components/ble/controller/bb;../../../components/ble/controller/bb/reg;../../../components/ble/controller/ll;../../../components/ble/controller/hci;../../../components/ble/controller/llt;../../../components/ble/common;../../../components/nvds;../../../components/evt;../../../components/crypto;../../../components/crypto/micro_ecc;../../../components/pm;../../../components/mbr;../../../components/trace;../../../hal/CMSIS/Core/Include;../../../hal/driver/include;../../../hal/device/include;../src;../../common;../../common/cs_ancs;../../common/cs_dfu;../../common/cs_gap_dis_batt;../../common/cs_hid_media;../../common/cs_tspp;../../../rtos/include;../../../rtos/FreeRTOS/Source/Include;../../../rtos/FreeRTOS/CMSIS/Config/ARMCM;../../../rtos/FreeRTOS/CMSIS/Include;../../../rtos/FreeRTOS/CMSIS/Include1;../../../rtos/FreeRTOS/Source/Portable/chipsea/GCC;../../../include;..\src
  asm define: CONFIG_CST92F41=1,CONFIG_LIB_PRESET_BLE_1PERIPHERAL,CONFIG_AUTOCONF_PRESET
  asm include: ../../../rtos/FreeRTOS/Source/Portable/cst92f41/GCC/port.c;../../../bsp/include;../../../bsp/CST92F4X_EVB;../../../common;../../../components/shell;../../../components/unity;../../../components/ble/include;../../../components/ble/controller/include;../../../components/ble/host/include;../../../components/ble/mesh/include;../../../components/ble/controller;../../../components/ble/controller/include;../../../components/ble/controller/main;../../../components/ble/controller/cc;../../../components/ble/controller/llp;../../../components/ble/controller/dbg;../../../components/ble/controller/ecc_p256;../../../components/ble/controller/co;../../../components/ble/controller/rf;../../../components/ble/controller/bb;../../../components/ble/controller/bb/reg;../../../components/ble/controller/ll;../../../components/ble/controller/hci;../../../components/ble/controller/llt;../../../components/ble/common;../../../components/nvds;../../../components/evt;../../../components/crypto;../../../components/crypto/micro_ecc;../../../components/pm;../../../components/mbr;../../../components/trace;../../../hal/CMSIS/Core/Include;../../../hal/driver/include;../../../hal/device/include;../src;../../common;../../common/cs_ancs;../../common/cs_dfu;../../common/cs_gap_dis_batt;../../common/cs_hid_media;../../common/cs_tspp;../../../rtos/include;../../../rtos/FreeRTOS/Source/Include;../../../rtos/FreeRTOS/CMSIS/Config/ARMCM;../../../rtos/FreeRTOS/CMSIS/Include;../../../rtos/FreeRTOS/CMSIS/Include1;../../../rtos/FreeRTOS/Source/Portable/chipsea/GCC;../../../include
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x14000
  scatter file: ../../../hal/device/chipsea/rom_lib/current/ARM/linker_flash.sct
  link misc: --diag_suppress=L6314W
--userlibpath=../../../hal/device/chipsea/rom_lib/current/ARM
--via=../../../hal/device/chipsea/rom_lib/current/ARM/linker_ble_1peripheral.via
  group bsp
    ../../../bsp/CST92F4X_EVB/: board_cst92f41_evb.c
  group shell
    ../../../components/shell/: shell.c shell_cmd.c shell_port.c
  group mbr
    ../../../components/mbr/: mbr.c
  group trace
    ../../../components/trace/: trc_io.c
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group projects
    ../src/: main.c sdk_config.h evt_task.c app_adv.c app_sec.c app_24g.c app_24g.h app_adv.h
    ../../common/cs_ancs/: ancs_client.c
    ../../common/cs_dfu/: chipsea_dfu.c chipsea_dfu_nvds.c service_chipsea_dfu.c
    ../../common/cs_gap_dis_batt/: service_common.c
    ../../common/cs_hid_media/: app_hid_media.c
  group pm
    ../../../components/pm/: pm.c
  group driver
    ../../../hal/driver/common/: drv_isr.c drv_usart.c drv_usart_ex.c drv_wdt.c drv_pmu_timer.c drv_cortex.c drv_24g.c drv_aes_hw.c drv_gpio.c drv_efuse.c drv_sf_base.c drv_sf_sys.c drv_sf.c drv_dma.c drv_spi.c drv_i2c.c drv_rtc.c drv_radio.c drv_tim.c drv_lp_tim.c drv_rng.c
    ../../../hal/driver/chipsea/: drv_pinmux.c drv_pmu.c drv_rcc.c drv_calib.c drv_calib_repair.c drv_adc.c
  group device
    ../../../hal/device/chipsea/: system.c startup.S system_asm.S
  group unity
    ../../../components/unity/: unity_fixture.c unity.c
  group ble
    ../../../components/ble/common/: cs_ble_mem_heap.c
  group rtos
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/Common/: mpu_wrappers.c
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os2.c freertos_evr.c cmsis_os1.c os_systick.c
    ../../../rtos/FreeRTOS/Source/Portable/chipsea/GCC/: port.c
  group common
    ../../../common/: cs_libc_retarget.c cs_printf.c cs_fifo.c cs_list.c cs_utils.c cs_log.c
  group crypto
    ../../../components/crypto/: sha256.c
    ../../../components/crypto/micro_ecc/: uECC.c
  group adapter
    ../../../chipsea_adapter/fault_handler/: adapter.c
    ../../../chipsea_adapter/fault_handler/keil/: cmb_fault.S
